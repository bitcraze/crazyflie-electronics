# Repository bitcraze/crazyflie-electronics

File README.md:

# Crazyflie Electronics
Datasheets and KiCad project files for the Crazyflie 1.0 electronics design.

For more information see the [wiki](https://wiki.bitcraze.io/projects:crazyflie:index)

## KiCad design ecad/Crazyflie contol board.kicad_pcb

Parts:
C1, C4, C5: 100nF; SM0603_Capa
C2, C3: 15pF; SM0603_Capa
C6, C7: 4.7uF; SM0603_Capa
C8: 10nF; SM0603_Capa
D1, D2, D3, D4: BAT54; SOD323
D5: RED LED; SMDLED-0603
D6: GREEN LED; SMDLED-0603
P1, P2, P3, P4, P5: CONN_2; PINHEADER_127_2X1
P6: CONN_10X2; PINHEADER_127_2X10
Q1, Q2, Q3, Q4: PMV31XN; SOT23GDS
R1, R2, R3, R4: 10k; SM0402
R5: 330R; SM0603
R6: 220R; SM0603
R7: 100k; SM0603
R8, R9: 10k; SM0603
R10, R11: NM; SM0603
R13, R14: 2.2k; SM0603
R39, R40, R41, R42: 100R; SM0402
U1: STM32F103CB; LQFP-48
X1: 16Mhz; XTAL-5.0x3.2

Connections:
+BATT: D1.2 (K), D2.2 (K), D3.2 (K), D4.2 (K), P1.1, P2.1, P3.1, P4.1; also elsewhere on the board
/BOOT0: R7.1, U1.44 (BOOT0)
/EXT_I2C_SCL/TX: P6.3, R9.2, R11.1, U1.21 (PB10/I2C2_SCL/U3_TX)
/EXT_I2C_SDA/RX: P6.5, R8.2, R10.1, U1.22 (PB11/I2C2_SCK/U3_RX)
/EXT_SPI_CS: P6.11, U1.14 (PA4/AIN4)
/EXT_SPI_MISO: P6.14, U1.16 (PA6/AIN6)
/EXT_SPI_MOSI: P6.12, U1.17 (PA7/AIN7)
/EXT_SPI_SCK: P6.13, U1.15 (PA5/AIN5)
/IMU/I2C_SCL_VCCA: R14.2, U1.42 (PB6/TIM4_CH1); also elsewhere on the board
/IMU/I2C_SDA_VCCA: R13.2, U1.43 (PB7/TIM4_CH2); also elsewhere on the board
/IMU/INT_GA: U1.3 (PC14/OSC32_IN); also elsewhere on the board
/LED_GREEN: R6.1, U1.41 (PB5)
/LED_RED: R5.1, U1.40 (PB4/JNTRST)
/MOTOR1: R39.1, U1.19 (PB1)
/MOTOR2: R40.1, U1.18 (PB0)
/MOTOR3: R41.1, U1.46 (PB9/TIM4_CH4)
/MOTOR4: R42.1, U1.45 (PB8/TIM4_CH3)
/POWER/CHG: U1.20 (PB2/BOOT1); also elsewhere on the board
/POWER/EN1: U1.2 (PC13/TAMPER-RTC); also elsewhere on the board
/POWER/EN2: U1.12 (PA2/AIN2); also elsewhere on the board
/POWER/PGOOD: U1.4 (PC15/OSC32_OUT); also elsewhere on the board
/POWER/SYSOFF: U1.11 (PA1/AIN1); also elsewhere on the board
/POWER/USBD+: U1.33 (PA12/USBDP); also elsewhere on the board
/POWER/USBD-: U1.32 (PA11/USBDM); also elsewhere on the board
/POWER/USB_CON: U1.10 (PA0/AIN0); also elsewhere on the board
/POWER/VBAT: U1.13 (PA3/AIN3); also elsewhere on the board
/SNRST: C1.1, P6.10, U1.7 (NRST)
/TCK: P6.4, U1.37 (PA14/JTCK)
/TDI: P6.8, U1.38 (PA15/JTDI)
/TDO: P6.6, U1.39 (PB3/JTD0)
/TMS: P6.2, U1.34 (PA13/JTMS)
/WIRELESS/SPI_MISO: U1.27 (PB14/SPI2_MISO); also elsewhere on the board
/WIRELESS/SPI_MOSI: U1.28 (PB15/SPI2_MOSI); also elsewhere on the board
/WIRELESS/SPI_SCK: U1.26 (PB13/SPI2_SCK); also elsewhere on the board
/WIRELESS/W_CE: U1.31 (PA10); also elsewhere on the board
/WIRELESS/W_CK: U1.29 (PA8/MCO); also elsewhere on the board
/WIRELESS/W_CS: U1.25 (PB12/SPI2_NSS); also elsewhere on the board
/WIRELESS/W_INT: U1.30 (PA9); also elsewhere on the board
AGND: C2.2, C3.2, C7.2, C8.2, P6.19, U1.8 (VSSA), X1.2 (GND), X1.4 (GND); also elsewhere on the board
DGND: C1.2, C4.2, C5.2, C6.2, P5.2 (PM), P6.9, P6.17, P6.18, R7.2, R10.2, R11.2, U1.23 (VSS_1), U1.35 (VSS_2), U1.47 (VSS_3); also elsewhere on the board
GND: Q1.S, Q2.S, Q3.S, Q4.S, R1.2, R2.2, R3.2, R4.2; also elsewhere on the board
unnamed: Q2.G, R2.1, R40.2
unnamed: Q3.G, R3.1, R41.2
unnamed: D3.1 (A), P3.2 (PM), Q3.D
unnamed: Q4.G, R4.1, R42.2
unnamed: C2.1, U1.5 (OSC_IN/PD0), X1.1
unnamed: C3.1, U1.6 (OSC_OUT/PD1), X1.3
unnamed: D6.2 (K), R6.2
unnamed: D5.2 (K), R5.2
unnamed: Q1.G, R1.1, R39.2
unnamed: D1.1 (A), P1.2 (PM), Q1.D
unnamed: D2.1 (A), P2.2 (PM), Q2.D
unnamed: D4.1 (A), P4.2 (PM), Q4.D
VCC: C4.1, C5.1, C6.1, D5.1 (A), D6.1 (A), P5.1, P6.1, P6.15, R8.1, R9.1, U1.1 (VBAT), U1.24 (VDD_1), U1.36 (VDD_2), U1.48 (VDD_3); also elsewhere on the board
VCCA: C7.1, C8.1, P6.20, R13.1, R14.1, U1.9 (VDDA); also elsewhere on the board
VCOM: P6.16; also elsewhere on the board

Notes on the sheet:
Structual support header
Mount pull-down (0R) and don't mount pull-up to comply with ARM 10-pin spec.
Coreless motor
Pin24
Pin36
Pin48

Parts:
C16: 10nF; SM0603_Capa
C17: 2.2nF; SM0603_Capa
C18, C20, C23, C24: 100nF; SM0603_Capa
C21: 0.22uF; SM0603_Capa
C22: 4.7uF; SM0603_Capa
U3: MPU60X0
U4: HMC5883L; QFN16_HMC5883L
U5: MS5611-01BA03; MS5611

Connections:
/IMU/I2C_SCL_VCCA: U3.23 (SCL/SCLK), U5.8 (SCLK); also elsewhere on the board
/IMU/I2C_SDA_VCCA: U3.24 (SDA/SDI), U5.7 (SDI/SDA); also elsewhere on the board
/IMU/INT_GA: U3.12 (INT); also elsewhere on the board
AGND: C16.2, C17.2, C18.2, C20.2, C22.2, C23.2, C24.2, U3.1 (CLKIN), U3.18 (GND), U4.9 (GND), U4.11 (GND), U5.3 (GND), U5.4 (CSB), U5.5 (CSB); also elsewhere on the board
unnamed: C21.2, U4.12 (SETC)
unnamed: C22.1, U4.10 (C1)
unnamed: C21.1, U4.8 (SETP)
unnamed: C18.1, U3.10 (REGOUT)
unnamed: U3.7 (AUX_CL), U4.1 (SCL)
unnamed: U3.6 (AUX_DA), U4.16 (SDA)
unnamed: C17.1, U3.20 (CPOUT)
VCCA: C16.1, C20.1, C23.1, C24.1, U3.8 (VLOGIC/CS), U3.9 (AD0/SDO), U3.13 (VDD), U4.2 (VDD), U4.4 (S1), U4.6 (I2C/SPI), U4.13 (VDDIO), U5.1 (VDD), U5.2 (PS); also elsewhere on the board

Notes on the sheet:
U5 not mounted on 6-DOF version
U4 not mounted on 6-DOF version

Parts:
C9: 1.5pF; SM0603_Capa
C10: 1.0pF; SM0603_Capa
C11: 2.2nF; SM0603_Capa
C12: 4.7pF; SM0603_Capa
C13: 10nF; SM0603_Capa
C14: 100nF; SM0603_Capa
C15: 33nF; SM0603_Capa
L1: 3.9nH; SM0603_Capa
L2: 8.2nH; SM0603_Capa
L3: 2.7nH; SM0603_Capa
R12: 22k; SM0603
U2: NRF24L01+; QFN20-4x4mm
Y1: CHIP_ANTENNA; CHIP-ANT-6.5x2.2

Connections:
/WIRELESS/SPI_MISO: U2.5 (MISO); also elsewhere on the board
/WIRELESS/SPI_MOSI: U2.4 (MOSI); also elsewhere on the board
/WIRELESS/SPI_SCK: U2.3 (SCK); also elsewhere on the board
/WIRELESS/W_CE: U2.1 (CE); also elsewhere on the board
/WIRELESS/W_CK: U2.10 (XC1); also elsewhere on the board
/WIRELESS/W_CS: U2.2 (CSN); also elsewhere on the board
/WIRELESS/W_INT: U2.6 (IRQ); also elsewhere on the board
DGND: C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, R12.2, U2.8 (GND), U2.14 (GND), U2.17 (GND), U2.20 (GND); also elsewhere on the board
unnamed: R12.1, U2.16 (IREF)
unnamed: C9.2, L1.1
unnamed: C9.1, C10.1, Y1.1
unnamed: C11.1, C12.1, L3.1, U2.11 (VDD_PA)
unnamed: C15.1, U2.19 (DVDD)
unnamed: L2.2, L3.2, U2.12 (ANT1)
unnamed: L1.2, L2.1, U2.13 (ANT2)
VCC: C13.1, C14.1, U2.7 (VDD), U2.15 (VDD), U2.18 (VDD); also elsewhere on the board

Parts:
BT1: BATTERY; JST-B2B-ZR
C29, C35: 15pF; SM0603_Capa
C30, C31, C34, C37: 4.7uF; SM0603_Capa
C32, C40: 10nF; SM0603_Capa
C33, C36, C38, C41: 100nF; SM0603_Capa
C39: 10uF; SM0603_Capa
D7, D8: BLUE LED; SMDLED-0603
P7: MICRO-B-USB; ZX62-B-5PA_11_CFK
P8: CONN_2; PINHEADER_127_2X1
P9: CONN_1; PINHEADER_127_1X1
Q5, Q6: 2N7002; SOT23GDS
R16: 39k; SM0603
R17: 10R; SM0603
R18, R28: 30k; SM0603
R19, R29: 0R; SM0603
R20: 42.2k; SM0603
R21: 300k; SM0603
R22, R38: 1k; SM0603
R23: 150k; SM0603
R24: 1.2k; SM0603
R25, R27, R32, R33, R36, R37: 10k; SM0603
R26: 1.2K; SM0603
R30: 20k; SM0603
R31: 100k; SM0603
SW1: PUSH ON/OFF; SPST-NO-4x2.5
U6: NUF2221; SOT363
U7, U9: TPS79301; SOT23_6
U8: BQ24075; QFN16
U10: MAX16054; SOT23_6

Connections:
+BATT: BT1.1 (+), C39.1, R30.2, U8.2 (BAT), U8.3 (BAT), U10.6 (VCC); also elsewhere on the board
/POWER/CHG: U8.9 (/CHG); also elsewhere on the board
/POWER/D+: P7.3 (D+), U6.6 (D1C)
/POWER/D-: P7.2 (D-), U6.4 (D2C)
/POWER/EN1: U8.6 (EN1); also elsewhere on the board
/POWER/EN2: U8.5 (EN2); also elsewhere on the board
/POWER/PGOOD: R21.1, R23.2, U8.7 (/PGOOD); also elsewhere on the board
/POWER/SYSOFF: R31.2, U10.3 (CLR); also elsewhere on the board
/POWER/USBD+: U6.1 (D1I); also elsewhere on the board
/POWER/USBD-: U6.3 (D2I); also elsewhere on the board
/POWER/USB_CON: U6.5 (VBUS); also elsewhere on the board
/POWER/VBAT: C41.1, Q5.S, R32.2; also elsewhere on the board
/POWER/VUSB: C36.1, P7.1 (VCC), P8.1, Q6.G, R37.2, U8.13 (IN)
AGND: C30.2, C32.2, R18.1, R19.1; also elsewhere on the board
DGND: C36.2, C37.2, C40.2, D7.2 (K), D8.2 (K), P7.5 (GND), P8.2 (PM), R28.1, R29.1, U6.2 (GND); also elsewhere on the board
GND: BT1.2 (-), C31.2, C33.2, C34.2, C38.2, C39.2, C41.2, P9.1, Q6.S, R19.2, R24.1, R25.1, R26.1, R27.1, R29.2, R31.1, R32.1, R36.1, R37.1, SW1.1, U7.2 (GND), U8.4 (/CE), U8.8 (VSS), U8.17 (TPAD), U9.2 (GND), U10.2 (GND); also elsewhere on the board
unnamed: R25.2, U8.14 (TMR)
unnamed: D8.1 (A), R38.1
unnamed: Q6.D, R33.2, U8.15 (SYSOFF)
unnamed: C35.2, R20.1, R23.1, R28.2, U9.5 (FB)
unnamed: C32.1, U7.4 (NR)
unnamed: C29.2, R16.1, R18.2, U7.5 (FB)
unnamed: R33.1, U10.4 (/OUT)
unnamed: R27.2, U8.1 (TS)
unnamed: R26.2, U8.16 (ISET)
unnamed: R24.2, U8.12 (ILIM)
unnamed: C40.1, U9.4 (NR)
unnamed: Q5.D, R30.1
unnamed: D7.1 (A), R22.1
unnamed: SW1.2, U10.1 (IN)
unnamed: C31.1, R17.1, U7.1 (IN), U7.3 (EN)
VCC: C35.1, C37.1, R20.2, R21.2, R22.2, R38.2, U9.6 (OUT); also elsewhere on the board
VCCA: C29.1, C30.1, R16.2, U7.6 (OUT); also elsewhere on the board
VCOM: C33.1, C34.1, C38.1, Q5.G, R17.2, R36.2, U8.10 (OUT), U8.11 (OUT), U9.1 (IN), U9.3 (EN); also elsewhere on the board

Notes on the sheet:
For KiCad ERC check
Analod LDO configured to 2.8V
When USB is connected digital LDO will give 3.3V otherwise 2.8V
Accumulated standby current is about 10uA. For a full 170mAh battery that would give >2 years of standby before depleated.
Standby current 3uA@3.7V
Max input current set to 1.3A Fastcharge current set to 740mA Safty timer is set to 80min No battery temp monitoring Standby current <7uA
DGND star connection @ LDO GND pin
AGND star connection @ LDO GND pin

Board: 4 copper layers, 80.0 x 80.0 mm, 119 parts (0 on the bottom side), 88 nets.

Other parts of the board:
PCB_EDGE1: VAL**; EDGE_S_LONG_USB
PCB_EDGE2, PCB_EDGE3, PCB_EDGE4: VAL**; EDGE_S_LONG

## Commit log

2013-07-29 Initial commit of Crazyflie electronics and datasheets.
2013-10-03 Updated board to new pcb layout format. Increased PCB arm curve thickness a tiny bit.
2016-02-01 Added license file

Notices in the files:
ecad/Crazyflie contol board.kicad_pcb:
Bitcraze AB (CC BY-NC-SA)
